# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\Lib\cmsis;..\Lib\inc;..\User\enc28j60;..\User\Net
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c usart.c
  group StdPeriph_Driver
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
  group CMSIS
    ../Lib/cmsis/: core_cm3.c
    ../User/: system_stm32f10x.c
  group Startup
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
  group Net
    ../User/Net/: ip_arp_udp_tcp.c simple_server.c
  group ENC28J60
    ../User/enc28j60/: ENC28J60.C SPI.C
